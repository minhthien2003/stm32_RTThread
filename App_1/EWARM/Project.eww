<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MAIN_PANEL_V2.ewp</path>
  </project>
  <batchBuild />
</workspace>
